## boards/arm/H01R0/board.yml
```yaml
board:
  name: H01R0
  full_name: H01R0
  vendor: st
  socs:
    - name: stm32g0b1xx
```
